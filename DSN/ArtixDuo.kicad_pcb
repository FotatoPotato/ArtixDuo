# Repository FotatoPotato/ArtixDuo (continued)

## KiCad design DSN/ArtixDuo.kicad_pcb (continued)

Schematic: FPGA_0.kicad_sch, FPGA 0

Parts:
C243, C244, C247, C250, C253: 10uF; C_0805_2012Metric; MFR PN GRM21BC71E106KE01K
C245, C248, C251, C254, C256, C258, C260, C262, C265, C267, C272, C278, C282, C286, C287, C291, C292, C296, C303, C304, C306, C308, C314, C315, C317, C320, C326, C329, C331, C335, C337, C339, C343, C346: 1uF; C_0402_1005Metric; MFR PN GRM153R61A105ME95D
C246, C249, C252, C255, C259, C273, C274, C276, C279, C284, C289, C290, C294, C295, C297, C298, C299, C300, C301, C309, C310, C312, C313: 100nF; C_0402_1005Metric; MFR PN GRM155R71E104KE14J
C257, C275, C293, C302, C321, C324, C347: 220uF; C_1210_3225Metric; MFR PN GRM32ER60J227ME05K
C261, C263, C264, C266, C268, C269, C277, C280, C281, C283, C285, C288, C305, C307, C316, C318, C330, C332, C340, C344: 10uF; C_0603_1608Metric; MFR PN GRM185R60J106ME15J
C270, C271: 47uF; C_1210_3225Metric; MFR PN GRM32ER70J476ME20L
C311, C319, C322, C323, C327, C328, C333, C334, C336, C341, C342, C348, C349, C356: 100nF; C_0402_1005Metric; MFR PN GRM155R71H104ME14J
C325: 47uF; C_1210_3225Metric
C338, C345: DNF; C_0402_1005Metric
D40: LED GREEN; LED_0603_1608Metric; MFR PN 150060VS75000
D41: LED RED; LED_0603_1608Metric; MFR PN 150060RS75000
J32: Conn_Coaxial; SMA_Amphenol_901-144_Vertical
L8: 100ohm; L_0402_1005Metric; MFR_PN 742792731
Q22: AO3401A; SOT-23
Q23: 2N7002K; SOT-23
R190, R201: 0R; R_0402_1005Metric
R191, R192: 100R; R_0402_1005Metric; MFR PN RC0402FR-07100RL
R193, R194, R197, R198, R199, R200, R204: 1K; R_0402_1005Metric
R195: 10K; R_0402_1005Metric; MFR PN RC0402FR-0710KP
R196: 2.4K; R_0402_1005Metric
R202, R203: 4.7K; R_0402_1005Metric
SW26: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W8.61mm_P2.54mm
SW27, SW28: SW_Push; SW_Push_1P1T_NO_CK_KMR2
TP15, TP16: TestPoint_Probe; TestPoint_Loop_D2.50mm_Drill1.85mm
U20: XC7A35T_FGG484
U21: SIT9120AI; Oscillator_SMD_SiTime_SiT9121-6Pin_3.2x2.5mm
U22: DSC1103BI2-135.0000; VDFN-6
U23: REF3012; SOT-23
U24, U25, U27, U28: TXB0108PWR; TSSOP-20_W4.4mm; MPN TXB0108PWR; Digi-Key_PN 296-21527-1-ND
U26: IS25LP128F; SOIC-8_3.9x4.9mm_P1.27mm; MFR PN IS25LP128F-JBLA3
U31: TC1047AVNBTR; SOT-23-3; MPN TC1047AVNBTR; Digi-Key_PN TC1047AVNBCT-ND

Connections:
+1V0: C246.1, C249.1, C252.1, C253.1, C255.1, C259.1, C264.1, C265.1, C269.1, C270.1, C275.1, C276.1, C277.1, C279.1, C281.1, C284.1, C286.1, C289.1, C292.1, C294.1, C296.1, C297.1, C299.1, U20.D6 (MGTAVCC), U20.D10 (MGTAVCC), U20.E8 (MGTAVCC), U20.F7 (MGTAVCC), U20.F9 (MGTAVCC), U20.H8 (VCCINT), U20.H10 (VCCINT), U20.J7 (VCCINT), U20.J9 (VCCINT), U20.J11 (VCCBRAM), U20.K8 (VCCINT), U20.L7 (VCCINT), U20.L11 (VCCBRAM), U20.M8 (VCCINT), U20.N7 (VCCINT), U20.N11 (VCCBRAM), U20.P8 (VCCINT), U20.P10 (VCCINT), U20.R7 (VCCINT), U20.R9 (VCCINT), U20.T8 (VCCINT), U20.T10 (VCCINT); also elsewhere on the board
+1V2: C250.1, C280.1, C285.1, C290.1, C295.1, C298.1, C300.1, C301.1, R192.2, U20.B5 (MGTAVTT), U20.B7 (MGTAVTT), U20.B9 (MGTAVTT), U20.B11 (MGTAVTT), U20.C4 (MGTAVTT), U20.C8 (MGTAVTT); also elsewhere on the board
+1V8: C245.1, C247.1, C248.1, C251.1, C254.1, C256.1, C260.1, C261.1, C266.1, C271.1, C327.1, C328.1, C337.1, C339.1, C340.1, C341.1, C342.1, C343.1, C344.1, C346.1, C347.1, U20.C1 (VCCO_35), U20.E12 (VCCBATT_0), U20.F2 (VCCO_35), U20.H6 (VCCO_35), U20.H12 (VCCAUX), U20.J3 (VCCO_35), U20.K10 (VCCADC_0), U20.K12 (VCCAUX), U20.M4 (VCCO_35), U20.M12 (VCCAUX), U20.N1 (VCCO_35), U20.P12 (VCCAUX), U20.R11 (VCCAUX), U24.2 (VCCA), U24.10 (OE), U25.2 (VCCA), U25.10 (OE), U27.2 (VCCA), U27.10 (OE), U28.2 (VCCA), U28.10 (OE); also elsewhere on the board
+3V3: C244.1, C257.1, C258.1, C262.1, C263.1, C267.1, C268.1, C272.1, C273.1, C274.1, C278.1, C282.1, C283.1, C287.1, C288.1, C291.1, C293.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C314.1, C315.1, C316.1, C317.1, C318.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C348.1, C349.1, C356.1, Q22.3 (D), R190.1, R193.2, R196.2, R197.2, R198.2, R199.2, R200.2, R202.2, R203.2, R204.2, U20.A17 (VCCO_16), U20.AA7 (VCCO_34), U20.AA17 (VCCO_13), U20.AB4 (VCCO_34), U20.AB14 (VCCO_13), U20.B14 (VCCO_16), U20.C21 (VCCO_16), U20.D18 (VCCO_16), U20.E15 (VCCO_16), U20.F12 (VCCO_0), U20.F22 (VCCO_16), U20.G19 (VCCO_15), U20.H16 (VCCO_15), U20.J13 (VCCO_15), U20.K20 (VCCO_15), U20.L17 (VCCO_15), U20.M14 (VCCO_14), U20.N21 (VCCO_15), U20.P18 (VCCO_14)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; also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_AIN_N: C338.2, C345.2, J32.2 (Ext), U20.M9 (VN_0)
/TopSheet/FPGA_0/FPGA_0_AIN_P: C338.1, R201.1, U20.L10 (VP_0)
/TopSheet/FPGA_0/FPGA_0_CCLK: U20.L12 (CCLK_0), U26.6 (SCK)
/TopSheet/FPGA_0/FPGA_0_CFGBVS: R200.1, U20.U8 (CFGBVS_0)
/TopSheet/FPGA_0/FPGA_0_DIN: U20.R22 (IO_L1N_T0_D01_DIN_14), U26.2 (SO(I01))
/TopSheet/FPGA_0/FPGA_0_DONE: Q23.1 (G), R195.1, U20.G11 (DONE_0)
/TopSheet/FPGA_0/FPGA_0_DOUT: U20.P22 (IO_L1P_T0_D00_MOSI_14), U26.5 (SI(IO0))
/TopSheet/FPGA_0/FPGA_0_FCS_B: R196.1, U20.T19 (IO_L6P_T0_FCS_B_14), U26.1 (CE#)
/TopSheet/FPGA_0/FPGA_0_GTP_CLK0_C_N: C313.1, U22.5 (OUT_N)
/TopSheet/FPGA_0/FPGA_0_GTP_CLK0_C_P: C312.1, U22.4 (OUT_P)
/TopSheet/FPGA_0/FPGA_0_GTP_CLK0_N: C313.2, U20.E6 (MGTREFCLK0N_216)
/TopSheet/FPGA_0/FPGA_0_GTP_CLK0_P: C312.2, U20.F6 (MGTREFCLK0P_216)
/TopSheet/FPGA_0/FPGA_0_GTP_CLK1_N: U20.E10 (MGTREFCLK1N_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_GTP_CLK1_P: U20.F10 (MGTREFCLK1P_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_INITB: Q22.1 (G), R203.1, U20.U12 (INIT_B_0)
/TopSheet/FPGA_0/FPGA_0_LED0: U20.P17 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED1: U20.P15 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED2: U20.R16 (IO_L22N_T3_A04_D20_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED3: U20.N13 (IO_L23P_T3_A03_D19_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED4: U20.N14 (IO_L23N_T3_A02_D18_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED5: U20.P16 (IO_L24P_T3_A01_D17_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED6: U20.R17 (IO_L24N_T3_A00_D16_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LED7: U20.N15 (IO_25_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO0: U20.J16 (IO_0_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO1: U20.H13 (IO_L1P_T0_AD0P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO2: U20.G13 (IO_L1N_T0_AD0N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO3: U20.G15 (IO_L2P_T0_AD8P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO4: U20.G16 (IO_L2N_T0_AD8N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO5: U20.J14 (IO_L3P_T0_DQS_AD1P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO6: U20.H14 (IO_L3N_T0_DQS_AD1N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO7: U20.G17 (IO_L4P_T0_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO8: U20.G18 (IO_L4N_T0_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO9: U20.J15 (IO_L5P_T0_AD9P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO10: U20.H15 (IO_L5N_T0_AD9N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO11: U20.H17 (IO_L6P_T0_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO12: U20.H18 (IO_L6N_T0_VREF_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO13: U20.J22 (IO_L7P_T1_AD2P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO14: U20.H22 (IO_L7N_T1_AD2N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO15: U20.H20 (IO_L8P_T1_AD10P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO16: U20.G20 (IO_L8N_T1_AD10N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO17: U20.K21 (IO_L9P_T1_DQS_AD3P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO18: U20.K22 (IO_L9N_T1_DQS_AD3N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO19: U20.M21 (IO_L10P_T1_AD11P_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO20: U20.L21 (IO_L10N_T1_AD11N_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO21: U20.J20 (IO_L11P_T1_SRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO22: U20.J21 (IO_L11N_T1_SRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO23: U20.J19 (IO_L12P_T1_MRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO24: U20.H19 (IO_L12N_T1_MRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO25: U20.K18 (IO_L13P_T2_MRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO26: U20.K19 (IO_L13N_T2_MRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO27: U20.L19 (IO_L14P_T2_SRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO28: U20.L20 (IO_L14N_T2_SRCC_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO29: U20.N22 (IO_L15P_T2_DQS_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO30: U20.M22 (IO_L15N_T2_DQS_ADV_B_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO31: U20.M18 (IO_L16P_T2_A28_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO32: U20.L18 (IO_L16N_T2_A27_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO33: U20.N18 (IO_L17P_T2_A26_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO34: U20.N19 (IO_L17N_T2_A25_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO35: U20.N20 (IO_L18P_T2_A24_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO36: U20.M20 (IO_L18N_T2_A23_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO37: U20.K13 (IO_L19P_T3_A22_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO38: U20.K14 (IO_L19N_T3_A21_VREF_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO39: U20.M13 (IO_L20P_T3_A20_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO40: U20.L13 (IO_L20N_T3_A19_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO41: U20.K17 (IO_L21P_T3_DQS_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO42: U20.J17 (IO_L21N_T3_DQS_A18_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO43: U20.L14 (IO_L22P_T3_A17_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO44: U20.L15 (IO_L22N_T3_A16_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO45: U20.L16 (IO_L23P_T3_FOE_B_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO46: U20.K16 (IO_L23N_T3_FWE_B_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO47: U20.M15 (IO_L24P_T3_RS1_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO48: U20.M16 (IO_L24N_T3_RS0_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO49: U20.M17 (IO_25_15); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO50: U20.F15 (IO_0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO51: U20.F13 (IO_L1P_T0_16)
/TopSheet/FPGA_0/FPGA_0_LINK_IO52: U20.F14 (IO_L1N_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO53: U20.F16 (IO_L2P_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO54: U20.E17 (IO_L2N_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO55: U20.C14 (IO_L3P_T0_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO56: U20.C15 (IO_L3N_T0_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO57: U20.E13 (IO_L4P_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO58: U20.E14 (IO_L4N_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO59: U20.E16 (IO_L5P_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO60: U20.D16 (IO_L5N_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO61: U20.D14 (IO_L6P_T0_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO62: U20.D15 (IO_L6N_T0_VREF_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO63: U20.B15 (IO_L7P_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO64: U20.B16 (IO_L7N_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO65: U20.C13 (IO_L8P_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO66: U20.B13 (IO_L8N_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO67: U20.A15 (IO_L9P_T1_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO68: U20.A16 (IO_L9N_T1_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO69: U20.A13 (IO_L10P_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO70: U20.A14 (IO_L10N_T1_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO71: U20.B17 (IO_L11P_T1_SRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO72: U20.B18 (IO_L11N_T1_SRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO73: U20.D17 (IO_L12P_T1_MRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO74: U20.C17 (IO_L12N_T1_MRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO75: U20.C18 (IO_L13P_T2_MRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO76: U20.C19 (IO_L13N_T2_MRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO77: U20.E19 (IO_L14P_T2_SRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO78: U20.D19 (IO_L14N_T2_SRCC_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO79: U20.F18 (IO_L15P_T2_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO80: U20.E18 (IO_L15N_T2_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO81: U20.B20 (IO_L16P_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO82: U20.A20 (IO_L16N_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO83: U20.A18 (IO_L17P_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO84: U20.A19 (IO_L17N_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO85: U20.F19 (IO_L18P_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO86: U20.F20 (IO_L18N_T2_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO87: U20.D20 (IO_L19P_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO88: U20.C20 (IO_L19N_T3_VREF_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO89: U20.C22 (IO_L20P_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO90: U20.B22 (IO_L20N_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO91: U20.B21 (IO_L21P_T3_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO92: U20.A21 (IO_L21N_T3_DQS_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO93: U20.E22 (IO_L22P_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO94: U20.D22 (IO_L22N_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO95: U20.E21 (IO_L23P_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO96: U20.D21 (IO_L23N_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO97: U20.G21 (IO_L24P_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO98: U20.G22 (IO_L24N_T3_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_LINK_IO99: U20.F21 (IO_25_16); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_M0: R197.1, SW26.1, U20.U11 (M0_0)
/TopSheet/FPGA_0/FPGA_0_M1: R198.1, SW26.2, U20.U10 (M1_0)
/TopSheet/FPGA_0/FPGA_0_M2: R199.1, SW26.3, U20.U9 (M2_0)
/TopSheet/FPGA_0/FPGA_0_MCU_IO0: U20.W22 (IO_L7N_T1_D10_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO1: U20.AA20 (IO_L8P_T1_D11_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO2: U20.AA21 (IO_L8N_T1_D12_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO3: U20.Y21 (IO_L9P_T1_DQS_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO4: U20.Y22 (IO_L9N_T1_DQS_D13_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO5: U20.AB21 (IO_L10P_T1_D14_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO6: U20.AB22 (IO_L10N_T1_D15_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO7: U20.U20 (IO_L11P_T1_SRCC_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_MCU_IO8: U20.V20 (IO_L11N_T1_SRCC_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO0: U25.20 (B1); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO1: U25.18 (B2); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO2: U25.17 (B3); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO3: U25.16 (B4); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO4: U25.15 (B5); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO5: U25.14 (B6); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO6: U25.13 (B7); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_IO7: U25.12 (B8); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO0: U20.K1 (IO_L7P_T1_AD6P_35), U25.1 (A1)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO1: U20.J1 (IO_L7N_T1_AD6N_35), U25.3 (A2)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO2: U20.H2 (IO_L8P_T1_AD14P_35), U25.4 (A3)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO3: U20.G2 (IO_L8N_T1_AD14N_35), U25.5 (A4)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO4: U20.K2 (IO_L9P_T1_DQS_AD7P_35), U25.6 (A5)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO5: U20.J2 (IO_L9N_T1_DQS_AD7N_35), U25.7 (A6)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO6: U20.J5 (IO_L10P_T1_AD15P_35), U25.8 (A7)
/TopSheet/FPGA_0/FPGA_0_PMOD0_LV_IO7: U20.H5 (IO_L10N_T1_AD15N_35), U25.9 (A8)
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO0: U24.20 (B1); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO1: U24.18 (B2); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO2: U24.17 (B3); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO3: U24.16 (B4); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO4: U24.15 (B5); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO5: U24.14 (B6); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO6: U24.13 (B7); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_IO7: U24.12 (B8); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO0: U20.K4 (IO_L13P_T2_MRCC_35), U24.1 (A1)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO1: U20.J4 (IO_L13N_T2_MRCC_35), U24.3 (A2)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO2: U20.L3 (IO_L14P_T2_SRCC_35), U24.4 (A3)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO3: U20.K3 (IO_L14N_T2_SRCC_35), U24.5 (A4)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO4: U20.M1 (IO_L15P_T2_DQS_35), U24.6 (A5)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO5: U20.L1 (IO_L15N_T2_DQS_35), U24.7 (A6)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO6: U20.M3 (IO_L16P_T2_35), U24.8 (A7)
/TopSheet/FPGA_0/FPGA_0_PMOD1_LV_IO7: U20.M2 (IO_L16N_T2_35), U24.9 (A8)
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO0: U27.20 (B1); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO1: U27.18 (B2); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO2: U27.17 (B3); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO3: U27.16 (B4); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO4: U27.15 (B5); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO5: U27.14 (B6); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO6: U27.13 (B7); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_IO7: U27.12 (B8); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO0: U20.K6 (IO_L17P_T2_35), U27.1 (A1)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO1: U20.J6 (IO_L17N_T2_35), U27.3 (A2)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO2: U20.L5 (IO_L18P_T2_35), U27.4 (A3)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO3: U20.L4 (IO_L18N_T2_35), U27.5 (A4)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO4: U20.N4 (IO_L19P_T3_35), U27.6 (A5)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO5: U20.N3 (IO_L19N_T3_VREF_35), U27.7 (A6)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO6: U20.R1 (IO_L20P_T3_35), U27.8 (A7)
/TopSheet/FPGA_0/FPGA_0_PMOD2_LV_IO7: U20.P1 (IO_L20N_T3_35), U27.9 (A8)
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO0: U28.20 (B1); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO1: U28.18 (B2); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO2: U28.17 (B3); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO3: U28.16 (B4); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO4: U28.15 (B5); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO5: U28.14 (B6); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO6: U28.13 (B7); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_IO7: U28.12 (B8); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO0: U20.P5 (IO_L21P_T3_DQS_35), U28.1 (A1)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO1: U20.P4 (IO_L21N_T3_DQS_35), U28.3 (A2)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO2: U20.P2 (IO_L22P_T3_35), U28.4 (A3)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO3: U20.N2 (IO_L22N_T3_35), U28.5 (A4)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO4: U20.M6 (IO_L23P_T3_35), U28.6 (A5)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO5: U20.M5 (IO_L23N_T3_35), U28.7 (A6)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO6: U20.P6 (IO_L24P_T3_35), U28.8 (A7)
/TopSheet/FPGA_0/FPGA_0_PMOD3_LV_IO7: U20.N5 (IO_L24N_T3_35), U28.9 (A8)
/TopSheet/FPGA_0/FPGA_0_PROGB: R202.1, SW27.1, U20.N12 (PROGRAM_B_0)
/TopSheet/FPGA_0/FPGA_0_PSRAM_CLK_N: U20.G4 (IO_L12N_T1_MRCC_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_CLK_P: U20.H4 (IO_L12P_T1_MRCC_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_CS: U20.B1 (IO_L1P_T0_AD4P_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D0: U20.E1 (IO_L3P_T0_DQS_AD5P_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D1: U20.D1 (IO_L3N_T0_DQS_AD5N_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D2: U20.E2 (IO_L4P_T0_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D3: U20.D2 (IO_L4N_T0_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D4: U20.G1 (IO_L5P_T0_AD13P_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D5: U20.F1 (IO_L5N_T0_AD13N_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D6: U20.F3 (IO_L6P_T0_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_D7: U20.E3 (IO_L6N_T0_VREF_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_RESET: U20.A1 (IO_L1N_T0_AD4N_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PSRAM_RWDS: U20.C2 (IO_L2P_T0_AD12P_35); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_PUDC_B: R204.1, U20.U22 (IO_L3P_T0_DQS_PUDC_B_14)
/TopSheet/FPGA_0/FPGA_0_RXL0_N: U20.A8 (MGTPRXN0_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL0_P: U20.B8 (MGTPRXP0_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL1_N: U20.C11 (MGTPRXN1_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL1_P: U20.D11 (MGTPRXP1_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL2_N: U20.A10 (MGTPRXN2_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL2_P: U20.B10 (MGTPRXP2_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL3_N: U20.C9 (MGTPRXN3_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_RXL3_P: U20.D9 (MGTPRXP3_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SPI_SMC_CS: U20.AB20 (IO_L15N_T2_DQS_DOUT_CSO_B_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SPI_SMC_RX: U20.AA19 (IO_L15P_T2_DQS_RDWR_B_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SPI_SMC_SCLK: U20.W19 (IO_L12P_T1_MRCC_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SPI_SMC_TX: U20.V19 (IO_L14N_T2_SRCC_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SW0: U20.AB18 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SW1: U20.U17 (IO_L18P_T2_A12_D28_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SW2: U20.U18 (IO_L18N_T2_A11_D27_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SW3: U20.P14 (IO_L19P_T3_A10_D26_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_SYSCLK_N: R191.1, U20.W20 (IO_L12N_T1_MRCC_14), U21.5 (OUT_N)
/TopSheet/FPGA_0/FPGA_0_SYSCLK_P: R191.2, U20.Y18 (IO_L13P_T2_MRCC_14), U21.4 (OUT_P)
/TopSheet/FPGA_0/FPGA_0_SYSRST: SW28.1, U20.V18 (IO_L14P_T2_SRCC_14)
/TopSheet/FPGA_0/FPGA_0_TCK: U20.V12 (TCK_0); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TDI: U20.R13 (TDI_0); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TDO: U20.U13 (TDO_0); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TMS: U20.T13 (TMS_0); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL0_N: U20.A4 (MGTPTXN0_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL0_P: U20.B4 (MGTPTXP0_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL1_N: U20.C5 (MGTPTXN1_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL1_P: U20.D5 (MGTPTXP1_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL2_N: U20.A6 (MGTPTXN2_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL2_P: U20.B6 (MGTPTXP2_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL3_N: U20.C7 (MGTPTXN3_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_TXL3_P: U20.D7 (MGTPTXP3_216); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_UART_RX: U20.R21 (IO_L2N_T0_D03_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_UART_TX: U20.P21 (IO_L2P_T0_D02_14); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO0: U20.T3 (IO_0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO1: U20.T1 (IO_L1P_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO2: U20.U1 (IO_L1N_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO3: U20.U2 (IO_L2P_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO4: U20.V2 (IO_L2N_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO5: U20.R3 (IO_L3P_T0_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO6: U20.R2 (IO_L3N_T0_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO7: U20.W2 (IO_L4P_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO8: U20.Y2 (IO_L4N_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO9: U20.W1 (IO_L5P_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO10: U20.Y1 (IO_L5N_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO11: U20.U3 (IO_L6P_T0_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO12: U20.V3 (IO_L6N_T0_VREF_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO13: U20.AA1 (IO_L7P_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO14: U20.AB1 (IO_L7N_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO15: U20.AB3 (IO_L8P_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO16: U20.AB2 (IO_L8N_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO17: U20.Y3 (IO_L9P_T1_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO18: U20.AA3 (IO_L9N_T1_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO19: U20.AA5 (IO_L10P_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO20: U20.AB5 (IO_L10N_T1_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO21: U20.Y4 (IO_L11P_T1_SRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO22: U20.AA4 (IO_L11N_T1_SRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO23: U20.V4 (IO_L12P_T1_MRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO24: U20.W4 (IO_L12N_T1_MRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO25: U20.R4 (IO_L13P_T2_MRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO26: U20.T4 (IO_L13N_T2_MRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO27: U20.T5 (IO_L14P_T2_SRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO28: U20.U5 (IO_L14N_T2_SRCC_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO29: U20.W6 (IO_L15P_T2_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO30: U20.W5 (IO_L15N_T2_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO31: U20.U6 (IO_L16P_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO32: U20.V5 (IO_L16N_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO33: U20.R6 (IO_L17P_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO34: U20.T6 (IO_L17N_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO35: U20.Y6 (IO_L18P_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO36: U20.AA6 (IO_L18N_T2_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO37: U20.V7 (IO_L19P_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO38: U20.W7 (IO_L19N_T3_VREF_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO39: U20.AB7 (IO_L20P_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO40: U20.AB6 (IO_L20N_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO41: U20.V9 (IO_L21P_T3_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO42: U20.V8 (IO_L21N_T3_DQS_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO43: U20.AA8 (IO_L22P_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO44: U20.AB8 (IO_L22N_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO45: U20.Y8 (IO_L23P_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO46: U20.Y7 (IO_L23N_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO47: U20.W9 (IO_L24P_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO48: U20.Y9 (IO_L24N_T3_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_USER_IO49: U20.U7 (IO_25_34); also elsewhere on the board
/TopSheet/FPGA_0/FPGA_0_VREF_N: C319.2, L8.2, U20.L9 (VREFN_0)
/TopSheet/FPGA_0/FPGA_0_VREF_P: C319.1, TP16.1, U20.M10 (VREFP_0), U23.2 (OUT)
/TopSheet/FPGA_0/SMC_IO0: U20.T21 (IO_L4P_T0_D04_14); also elsewhere on the board
/TopSheet/FPGA_0/SMC_IO1: U20.U21 (IO_L4N_T0_D05_14); also elsewhere on the board
/TopSheet/FPGA_0/TSNS_FPGA0: TP15.1, U31.2 (VOUT); also elsewhere on the board
unnamed: C345.1, J32.1 (In), R201.2
unnamed: D40.1 (K), Q23.3 (D)
unnamed: D40.2 (A), R193.1
unnamed: D41.1 (K), R194.2
unnamed: D41.2 (A), Q22.2 (S)
unnamed: R190.2, U21.1 (NC/OE/ST)
unnamed: R192.1, U20.F8 (MGTRREF_216)

Notes on the sheet:
Pullups on USB_UART_JTAG Sheet
PROGRAM & DEVICE RESET
PROG DONE
Device Reset (Does not clear config)
FPGA USER IO
CONFIG STATUS
135Mhz Reference CLK
INIT DONE
200Mhz System CLK
FPGA MODE SELECT
Required Artix_7 Voltage rails
FPGA_INITB will Go Low once initialization is done
XADC ANALOG INPUT
Program Reset (clears config)
Required Pull_up's
FPGA ADC VREF
INIT_B Already Has Pullup, no need for FET Gate Pullup
FPGA CONFIG MEMORY
1.25V
FPGA_DONE will go High once Programming is done
Flash Memory selected from UG908
3.3V 1.8V 1.2V 1V
VCCINT _ 1V VCCAUX _ 1.8V VCCBRAM _ 1V VCCO _ 3.3V VCCBATT _ 1.8V VCCMGTAVCC _ 1V VCCMGTAVTT _ 1.2V VCCMGTREFCLK _ 1.2V VCCADC _ 1.8V VREFP _ 1.25V
FPGA to FPGA 100-Bit Bus
SPI FLASH _> 100 (M0,M1,M2) JTAG _> 101 (M0,M1,M2) M0_2 default HIGH, Turning on SW pulls LOW SEE UG470 FOR MORE INFO
